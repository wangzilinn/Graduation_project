# Keil uVision project Ucosii.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ucosii +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\UCOSII\PORT;..\UCOSII\CORE;..\UCOSII\CONFIG;..\HARDWARE\;..\MAIN;..\APP\;..\TRANSMISSION
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress L6776W
  group UCOSII
    ../UCOSII/CORE/: os_core.c os_mbox.c os_flag.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../UCOSII/PORT/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.S
    ../UCOSII/CONFIG/: os_cfg.h
  group HARDWARE
    ../HARDWARE/: bsp.cpp led.cpp usart.cpp delay.cpp dht11.cpp bitBand.cpp
  group MAIN
    ../MAIN/: main.cpp
  group APP
    ../APP/: task.cpp method.cpp stm32f10x_it.cpp debug.cpp
  group TRANSMISSION
    ../TRANSMISSION/: transportLayer.cpp
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
